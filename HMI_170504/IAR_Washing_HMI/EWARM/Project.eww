<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I_Washing_HMI.ewp</path>
  </project>
  <batchBuild />
</workspace>
